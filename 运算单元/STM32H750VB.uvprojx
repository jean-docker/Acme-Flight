# Keil uVision project STM32H750VB.uvprojx, settings and files
target Project (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32H750VBTx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.2.2.0
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x24000000-0x2407FFFF) IROM(0x8000000-0x801FFFF) CLOCK(12000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE
  output: STM32H750VB +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32H750xx
  c include: ./Drivers/STM32H7xx_HAL_Driver/Inc;./Drivers/STM32H7xx_HAL_Driver/Inc/Legacy;./Drivers/CMSIS/Device/ST/STM32H7xx/Include;./Drivers/CMSIS/Include;.\System;.\User;.\Hardware;.\FreeRTOS
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  group User
    ./User/: main.c stm32h7xx_it.c
  group HALLIB
    ./Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal.c stm32h7xx_hal_mdma.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_cortex.c stm32h7xx_hal_hsem.c
  group System
    ./System/: stm32h7xx_hal_msp.c system_stm32h7xx.c startup_stm32h750xx.s System_Config.c
  group FreeRTOS
    ./FreeRTOS/: list.c port.c queue.c tasks.c timers.c heap_5.c
software components: CMSIS:CORE 4.3.0
