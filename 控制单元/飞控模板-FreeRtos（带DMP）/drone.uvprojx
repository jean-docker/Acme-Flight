# Keil uVision project drone.uvprojx, settings and files
target drone (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: drone +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: .\User;.\System;.\FreeRTOS;.\Libraries;.\Hardware;.\CMSIS;.\STARTUP;.\DMP_LIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group STARTUP
    ./STARTUP/: startup_stm32f10x_md.s
  group CMSIS
    ./CMSIS/: system_stm32f10x.c core_cm3.c
  group Libraries
    ./Libraries/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group FreeRTOS
    ./FreeRTOS/: heap_4.c list.c port.c tasks.c timers.c
  group User
    ./USER/: main.c
    ./User/: stm32f10x_it.c
  group System
    ./System/: Bsp_RCC.c Bsp_USART1.c Bsp_USART2.c Bsp_LED.c Bsp_PWM.c Bsp_ADC.c
  group DMP_LIB
    ./DMP_LIB/: MPU6050.c IOI2C.c delay.c inv_mpu.c inv_mpu_dmp_motion_driver.c
