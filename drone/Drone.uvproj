# Keil uVision project Drone.uvproj, settings and files
target Drone (MCS-51)
  device: N76E003 Nuvoton
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x47FF)  XRAM(0 - 0x2FF) CLOCK(16000000)
  output: Drone +hex
  c flags: Optimize=8 SizeSpeed=1
  c define: FOSC_160000
  c include: .\USER;.\Common;.\Include;.\Startup;.\HARDWARE;.\SYSTEM
  group Startup
    ./Startup/: STARTUP.A51
  group Lib_Include
    ./Include/: Common.h Delay.h Function_Define.h N76E003.h SFR_Macro.h
  group Lib_Common
    ./Common/: Common.c Delay.c
  group USER
    ./USER/: main.c
  group SYSTEM
    ./SYSTEM/: SysClk.c GPIO.c PWM.c ADC.c UART.c I2C.c
